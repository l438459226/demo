# Keil uVision project USMART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USMART +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,ARM_MATH_CM3
  c misc: --C99
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\USMART;..\HARDWARE\ADC;..\HARDWARE\EXTI;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\SSD;..\HARDWARE\TIMER;..\MALLOC;..\HARDWARE;..\CMSIS\Include;..\STM32F10x_DSP_Lib\inc;..\HARDWARE\FRICKER;..\HARDWARE\IIC;..\HARDWARE\LT35825;..\HARDWARE;..\HARDWARE\PMU;..\HARDWARE\lcmparm;..\HARDWARE\UART_DMA;..\HARDWARE\Ymodem;..\HARDWARE\Appinterface;..\HARDWARE\user;..\HARDWARE\Protocol;..\HARDWARE\CRC16;..\HARDWARE\SSD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/user/: user.c
    ../HARDWARE/SSD/: ili9881c.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_flash.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group malloc
    ../MALLOC/: malloc.c
  group armdsplib
    ../CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
  group asmdsp
    ../STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s fir_stm32.s iirarma_stm32.s PID_stm32.s
    ../STM32F10x_DSP_Lib/src/: iir_stm32.c PID_C_stm32.c
  group Fricker
    ../HARDWARE/FRICKER/: Fricker.c
  group IIC
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/PMU/: i2c1_bitbang.c
  group LT35825
    ../HARDWARE/LT35825/: LT35825.c
  group test
    ../HARDWARE/: LT3582.c
  group PMU
    ../HARDWARE/PMU/: act8846.c TPS22993.c LM36923.c tps65132.c tps65651.c AD715.c INA226.c VoltCurrentProc.c
    ../HARDWARE/LED/: GPIO_Config.c
  group lcmparm
    ../HARDWARE/lcmparm/: parm.c
  group UARTDMA
    ../HARDWARE/UART_DMA/: Uart.c UartQue.c
  group Ymode
    ../HARDWARE/Ymodem/: common.c download.c upload.c ymodem.c
  group AppInterface
    ../HARDWARE/Appinterface/: appInterface.c
  group Protocol
    ../HARDWARE/Protocol/: Protocol.c
  group CRC16
    ../HARDWARE/CRC16/: CRC16.c
  group SSD2828
    ../HARDWARE/SSD/: ssd2828.c LCM.c gxnussd2828.c
