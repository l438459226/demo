# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  AfterMake: D:\ARM\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o ../output/iap.bin ../OBJ/LED.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\Appinterface
  memory RVCT4: ROM 0x2000c000 size 0x3000
  memory RVCT9: RAM 0x2000f000 size 0x1000
  group USER
    ./: main.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c
  group interface
    ../HARDWARE/Appinterface/: appInterface.c
